[aimspice]
[description]
112
Low-Pass Circuit
R1 a b 1k
C1 b 0 470n
!Vin a 0 DC 5 sin(0 5 1k 0 0)
Vin a 0 DC 5 pulse(0 5 0 0 0 1e-3 2e-3)
[tran]
1e-9
6e-3
X
X
0
[ana]
4 1
0
1 1
1 1 -6 6
2
v(a)
v(b)
[end]
